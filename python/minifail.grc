<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>minifail</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import ofdm.utils</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length_tag_name</value></param>
<param><key>value</key><value>"length"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>gr_tag_debug</key>
<param><key>id</key><value>gr_tag_debug_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Post-Copy</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>fft_len</value></param>
<param><key>display</key><value>True</value></param>
</block>
<block>
<key>gr_tag_debug</key>
<param><key>id</key><value>gr_tag_debug_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Start</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>display</key><value>True</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_tag_debug</key>
<param><key>id</key><value>gr_tag_debug_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Post-Alloc</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>fft_len</value></param>
<param><key>display</key><value>True</value></param>
</block>
<block>
<key>gr_kludge_copy</key>
<param><key>id</key><value>gr_kludge_copy_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>vlen</key><value>64</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>input_size</key><value>fft_len</value></param>
<param><key>output_size</key><value>fft_len+cp_len</value></param>
<param><key>tagname</key><value>length_tag_name</value></param>
<param><key>mtu</key><value>4096</value></param>
</block>
<block>
<key>ofdm_carrier_allocator_cvc</key>
<param><key>id</key><value>ofdm_carrier_allocator_cvc_0</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>occupied_carriers</key><value>(range(1, 27) + range(38, 64),)</value></param>
<param><key>pilot_carriers</key><value>((0,),)</value></param>
<param><key>pilot_symbols</key><value>((100,),)</value></param>
<param><key>tag_len_key</key><value>length_tag_name</value></param>
<param><key>mtu</key><value>4096</value></param>
</block>
<block>
<key>gr_head</key>
<param><key>id</key><value>gr_head_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>64*10*10000</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>[random.randint(0, 255) for i in range(64*10)]</value></param>
<param><key>tags</key><value>ofdm.utils.make_lengthtags((64*10,), (0,), length_tag_name)</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>ofdm_carrier_allocator_cvc_0</source_block_id><sink_block_id>gr_kludge_copy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_kludge_copy_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_1</source_block_id><sink_block_id>gr_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_head_0</source_block_id><sink_block_id>ofdm_carrier_allocator_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_carrier_allocator_cvc_0</source_block_id><sink_block_id>gr_tag_debug_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>gr_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_kludge_copy_0</source_block_id><sink_block_id>gr_tag_debug_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_head_0</source_block_id><sink_block_id>gr_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_carrier_allocator_cvc_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
